# IAR project FSStation.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: STM32F100x4 ST STM32F100x4
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: STM32F10X_LD_VL; ARM_MATH_CM3
  ICCARM.CCIncludePath2: .\CMSIS\CM3\DeviceSupport\ST\STM32F10x\
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: FSStation.hex
  ILINK.IlinkOutputFile: FSStation.out
  ILINK.IlinkIcfFile: C:\Disk D\My_projects\IAR ARM\SolderStation\FSStation.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  group (top)
    ./: main.c
  group CMSIS
    CMSIS/CM3/CoreSupport/: core_cm3.c core_cm3.h
    CMSIS/CM3/DeviceSupport/ST/STM32F10x/startup/iar/: startup_stm32f10x_ld_vl.s
    CMSIS/CM3/DeviceSupport/ST/STM32F10x/: stm32f10x.h system_stm32f10x.c system_stm32f10x.h
